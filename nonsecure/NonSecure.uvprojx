# Keil uVision project NonSecure.uvprojx, settings and files
target NonSecure (6240000::V6.24::ARMCLANG)
  device: M2354KJFAE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.4
  cpu: IRAM(0x20000000,0x40000) IRAM2(0x30000000,0x40000) IROM(0x00000000,0x100000) IROM2(0x10000000,0x100000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: NonSecure +hex
  AfterMake: fromelf --bin ".\bin\obj\@L.axf" --output ".\bin\obj\@L.bin"
  AfterMake: fromelf --text -c ".\bin\obj\@L.axf" --output ".\bin\obj\@L.txt"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: DEBUG_PORT=UART0_NS
  c misc: -fshort-enums -fshort-wchar  -fno-short-wchar -include predefines.h -include options_def.h
  c include: ..\secure\include;..\include;..\M2354BSP\Library\CMSIS\Include;..\M2354BSP\Library\Device\Nuvoton\M2354\Include;..\M2354BSP\Library\StdDriver\inc;..\AxioCrypto_dist\2.0.0\axiocrypto_nonsecure_sdk\include;..\FreeRTOS-Kernel\include;..\FreeRTOS-Kernel\portable\GCC\ARM_CM23\non_secure;..\FreeRTOS-Kernel\portable\GCC\ARM_CM23\secure;include;src\App\common;src\App;src\App\debug;src\App\dm;src\App\platform\dev;src\App\platform\drivers\at24cm02_e2prom;src\App\platform\drivers\mx25r4035f;src\App\platform\sec_meter;src\App\platform\sec_meter\afe;src\App\platform\sec_meter\app;src\App\platform\sec_meter\autocal;src\App\platform\sec_meter\bat;src\App\platform\sec_meter\ce;src\App\platform\sec_meter\cli;src\App\platform\sec_meter\dev;src\App\platform\sec_meter\dlms;src\App\platform\sec_meter\flash;src\App\platform\sec_meter\isotp;src\App\platform\sec_meter\LCD;src\App\platform\sec_meter\meter;src\App\platform\sec_meter\pm;src\App\platform\sec_meter\rtc;src\App\platform\sec_meter\sec;src\App\platform\sec_meter\serial;src\App\platform\sec_meter\timer;src\App\platform\sec_meter\tmp;src\App\platform\sec_meter\util;src\App\shell;src\App\sys\os_wrap;src\App\task;src\App\utils;src;..\libs\hls\include;src\App\platform\drivers\SPI_EEPROM;.\src\App\platform\drivers\EADC_VBat;..\M2354BSP\ThirdParty\mbedTLS\include\mbedtls;..\libs\mbedtls\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x30000000 size 0x40000
  scatter file: nonsecure.sct
  group User
    src/: main.c freertos_default.c hexdump.c
  group CMSIS
    ../cmsis/: system_M2354.c startup_M2354.s
  group Library
    ../secure/lib/: nsclib.o
    ../M2354BSP/Library/StdDriver/src/: uart.c gpio.c i2c.c spi.c lcd.c retarget.c eadc.c can.c
  group axiocrypto_nonsecure_sdk
    ../AxioCrypto_dist/2.0.0/axiocrypto_nonsecure_sdk/clang/: axiocrypto_sdk.lib
    ../libs/mbedtls/: axiocrypto_mbedtls.a
  group AxioCrypto_hls
    ../libs/hls/: AxioCrypto_hls.lib
  group FreeRTOS
    ../FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS-Kernel/portable/GCC/ARM_CM23/non_secure/: port.c portasm.c
    ../M2354BSP/ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Common
    src/App/common/: utils.c
  group debug
    src/App/debug/: amg_debug.c
  group dm
    src/App/dm/: amg_dm_main.c
  group platform_dev
    src/App/platform/dev/: amg_gpio.c amg_lcd.c amg_pwr.c amg_rtc.c amg_spi.c amg_timer.c amg_uart.c amg_wdt.c flash_if.c platform.c
    ./src/App/platform/dev/: amg_can.c
  group platform_drivers_at24cm02_e2prom
    src/App/platform/drivers/at24cm02_e2prom/: eeprom_at24cm02.c
  group platform_drivers_eadc_vbat
    ./src/App/platform/drivers/EADC_VBat/: eadc_vbat.c
  group platform_drivers_mx25r4035f
    src/App/platform/drivers/mx25r4035f/: mx25r4035f.c mx25r4035f-interface.c
  group platform_drivers_SPI_EEPROM
    ./src/App/platform/drivers/SPI_EEPROM/: STM32_EEPROM_SPI.c
  group platform_sec_meter
    src/App/platform/sec_meter/: amg_dlms_hdlc.c amg_media_mnt.c amg_meter_main.c amg_mif_prtl.c amg_modemif_prtl.c amg_mtp_process.c
    ./src/App/platform/sec_meter/: amg_secu_main.c
  group platform_sec_meter_afe
    src/App/platform/sec_meter/afe/: afe.c
  group platform_sec_meter_app
    src/App/platform/sec_meter/app/: disp.c eob.c eoi.c key.c keyinput.c lp.c nv.c program.c softimer.c whm.c whm_1.c whm_log.c
  group platform_sec_meter_autocal
    src/App/platform/sec_meter/autocal/: cal.c
  group platform_sec_meter_bat
    src/App/platform/sec_meter/bat/: batmode.c
    ./src/App/platform/sec_meter/bat/: bat.c
  group platform_sec_meter_cli
    src/App/platform/sec_meter/cli/: delay.c
  group platform_sec_meter_dlms
    src/App/platform/sec_meter/dlms/: aarq.c act_req.c amg_imagetransfer.c amg_push_datanoti.c appl.c approc.c comm.c dl.c dlms_todo.c get_req.c phy.c set_req.c
  group platform_sec_meter_meter
    src/App/platform/sec_meter/meter/: meter.c meter_app.c mmath.c pulse_src.c
  group platform_sec_meter_pm
    src/App/platform/sec_meter/pm/: amg_power_mnt.c amg_stock_op_mode.c
  group platform_sec_meter_rtc
    src/App/platform/sec_meter/rtc/: rtc.c
  group platform_sec_meter_sec
    src/App/platform/sec_meter/sec/: amg_sec.c
  group platform_sec_meter_serial
    src/App/platform/sec_meter/serial/: ser.c ser1.c
  group platform_sec_meter_timer
    src/App/platform/sec_meter/timer/: timer.c
  group platform_sec_meter_tmp
    src/App/platform/sec_meter/tmp/: tmp.c
  group platform_sec_meter_util
    src/App/platform/sec_meter/util/: dbgprintf.c
  group platform_sec_meter_isotp
    ./src/App/platform/sec_meter/isotp/: amg_isotp_user.c isotp.c
  group shell
    src/App/shell/: amg_shell.c amg_shell_flash.c amg_shell_modem.c amg_shell_peri.c amg_shell_product.c
  group sys_os_wrap
    src/App/sys/os_wrap/: os_list.c os_msgq.c os_pipe.c os_task_q.c os_wrap.c
  group utils
    src/App/utils/: amg_crc.c amg_sprintf.c amg_sw_timer.c amg_task_primitive.c amg_time.c amg_utc_util.c
